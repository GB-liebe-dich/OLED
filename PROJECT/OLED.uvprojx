# Keil uVision project OLED.uvprojx, settings and files
target QD-OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST_OLED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\DHT11;..\Logic\CLibrary;..\Logic\Display;..\HARDWARE\RTC;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE\ESP8266;..\HARDWARE\USART;..\HARDWARE\Button
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c test.c gui.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ESP8266/: ESP8266.c
    ../HARDWARE/USART/: USART3.c
    ../HARDWARE/Button/: Button.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c
  group Logic
    ../Logic/CLibrary/: CLibrary.c
    ../Logic/Display/: display.c
software components: CMSIS:CORE 4.3.0
